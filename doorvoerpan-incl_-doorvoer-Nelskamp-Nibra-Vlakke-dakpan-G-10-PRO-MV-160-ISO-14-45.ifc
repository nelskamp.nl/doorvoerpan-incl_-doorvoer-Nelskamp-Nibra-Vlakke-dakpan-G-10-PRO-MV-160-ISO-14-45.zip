Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 583befa6-db08-44c9-9f84-78e43c6faa3c.ifc
Time: 2025-01-21T09:37:49
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcFlowTerminal, doorvoerpan incl. doorvoer Nelskamp - Nibra Vlakke dakpan G-10 PRO MV 160 ISO 14-45
In: Bouwlaag
Material: terracotta
Pset_Data - WUID: AgAAAPXmCNsEAAAAkNICAAVc6AAAj6cAADxtAQC41gIA3tYCAAIAAQUBAQAAAAEAAACDAAEBAAAAAgAAAAAAAACvXNpzbJfcQ5RoBTXbV_yIBVaQAACGUgAAIdcAAIjVAgCe1wIAAAC-DQEABWYEAAA0lwAAPG0BAPZ6AAChgwAAAQAQAAEBAAAAAwAAALk8AAAF9rYAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAPXmCNsEAAAAkNICAAVc6AAAj6cAADxtAQC41gIA3tYCAAIAAQUBAQAAAAEAAACDAAEBAAAAAgAAAAAAAACvXNpzbJfcQ5RoBTXbV_yIBVaQAACGUgAAIdcAAIjVAgCe1wIAAAC-DQEABWYEAAA0lwAAPG0BAPZ6AAChgwAAAQAQAAEBAAAAAwAAALk8AAAF9rYAAGQwAADGpwAAo60AAOnYAAAAAA)); merk: Nelskamp; type: MV 160 ISO 14-45; kenmerkende grondstof: terracotta; serie: Nibra Vlakke dakpan G-10 PRO; tussenpan: keramische tussenpan Nelskamp - Nibra Vlakke dakpan G-10 PRO natuurrood (601); doorvoerelement: dakpandoorvoer ISO 15x15 15-45 Nelskamp - MV 160 ISO 14-45
